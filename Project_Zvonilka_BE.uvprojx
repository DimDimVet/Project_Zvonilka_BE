# Keil uVision project Project_Zvonilka_BE.uvprojx, settings and files
target Project_Zvonilka_BE (6190000::V6.19::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project_Zvonilka_BE
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=4
  c include: ..\Project_Zvonilka_BE;.\app;.\GPIO;.\RCC;.\I2C;.\SSD
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ./app/: app.c app.h lib_stm32.c lib_stm32.h
  group GPIO
    ./GPIO/: GPIO_STM32F407.c GPIO_STM32F407.h
  group RCC
    ./RCC/: RCC_STM32F407.c RCC_STM32F407.h
  group I2C
    ./I2C/: I2C_STM32F407.c I2C_STM32F407.h
  group SSD
    ./SSD/: SSD_1306.c SSD_1306.h fonts.h fonts.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
